File: powersupply.kicad_sch (KiCad schematic)
At the start: 3 parts, among them J1 Screw_Terminal_01x02, U1 3V3, U2 5V

Commit message: LAN PHy
Parts:
- renumbered J1 to J10
