File: GA_Fuelstation_Terminal.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: LAN PHy
Other:
- added sheet LAN (LAN.kicad_sch)
